RDEPENDS:packagegroup-rpb:append = "\
    i2c-tools \
    stress-ng \
    pciutils \
    bc \
    lmsensors \
    mpv \
    canutils \
    ethtool \
    devmem2 \
    iperf3 \
    blueman \
    bluez5 \
    packagegroup-core-buildessential \
    android-tools \
    "


RDEPENDS:packagegroup-rpb:append = "\
	phoronix-test-suite \
	dbench-dev \
	dhrystone \
	fio \
	googlebenchmark-dev \
	iozone3 \
	libc-bench \
	lmbench \
	nbench-byte \
	s-suite \
	sysbench \
	tinymembench \
	tiobench \
	whetstone \
	cmake \
	libgpiod \
	libgpiod-tools \
	libgpiod-dev \
	glmark2 \
	"
